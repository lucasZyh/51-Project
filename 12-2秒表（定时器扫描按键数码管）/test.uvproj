# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Timer0.h Delay.c Delay.h Timer0.c Keyplus.c Keyplus.h Shuplus.c Shuplus.h I2C.c I2C.h AT24C02.c AT24C02.h
