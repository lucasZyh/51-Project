# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h Key.c Key.h Shu.c Shu.h Timer1.c Timer1.h Timer0.h Int0.c Int0.h IR.c IR.h Timer0.c Motor.h Motor.c
